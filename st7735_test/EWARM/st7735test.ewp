# IAR project st7735test.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: randtestili9341.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\Drivers\STM32F10x_StdPeriph_Driver\inc\; ..\..\Drivers\STM32F10x_StdPeriph_Driver\src\; ..\..\Drivers\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; ..\..\Drivers\systicktimer\; ..\..\Drivers\spi\; ..\..\Drivers\gfx_tft\; ..\..\Drivers\ST7735\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: randtestili9341.bin
  ILINK.IlinkIcfFile: f103c8t6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
  group Drivers/GFX_TFT
    ../../Drivers/gfx_tft/: fonts.h gfx.c gfx.h
  group Drivers/GFX_TFT/ST7735
    ../../Drivers/ST7735/: st7735.c st7735.h
  group Drivers/SPI
    ../../Drivers/spi/: spi.c spi.h
  group Drivers/SysTickTimer
    ../../Drivers/systicktimer/: systicktimer.c systicktimer.h
  group STM32_SPL_Core/inc
    ../../Drivers/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_dma.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_spi.h
  group STM32_SPL_Core/src
    ../../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
  group STM32_SPL_Core/Startup
    ../../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group STM32_SPL_Core/STM32F10x
    ../../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
